CONNECTIVITY_FIRMWARES:append:board-template = " \
    <any device specific firmware files that are not meant to be provided by meta-balena can be specified here>
"
