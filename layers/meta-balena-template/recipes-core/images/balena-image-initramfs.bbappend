PACKAGE_INSTALL:append:board-template = " <if any package is needed in the initramfs, it should be placed here>"
