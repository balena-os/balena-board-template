# Identification LED can be specified here
LED_FILE:board-template = "/sys/class/leds/led0/brightness"
