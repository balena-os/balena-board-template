# Specify board specific TTYs
TTYS:board-template=" ttyS0 tty1"
