# Flash to internal eMMC - kernel enumerates this, when SD card is in, as mmcblk0. This is needed for flasher types only.
INTERNAL_DEVICE_KERNEL = "mmcblk0"
